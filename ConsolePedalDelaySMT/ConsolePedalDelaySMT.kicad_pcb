# Repository tmcdonagh/PCBFiles (continued)

## KiCad design ConsolePedalBlueSoxSMT/ConsolePedalBlueSoxSMT.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 60.0 mm, 53 parts (0 on the bottom side), 33 nets.

File ConsolePedalBlueSoxSMT/assembly/BlueSoxSMT-BOM.csv:

Comment,Designator,Footprint,LCSC
10nF,"C1,C9",Capacitor_SMD:C_0603_1608Metric,C57112
100uF,"C100,C102",Capacitor_SMD:CP_Elec_6.3x5.3,C176674
100nF,C103,Capacitor_SMD:C_0603_1608Metric,C14663
1nF,C2,Capacitor_SMD:C_0603_1608Metric,C1588
150pF,"C3,C10",Capacitor_SMD:C_0603_1608Metric,C1594
10uF,"C4,C101",Capacitor_SMD:CP_Elec_4x5.4,C72485
47nF,"C5,C8",Capacitor_SMD:C_0603_1608Metric,C1622
1uF,"C6,C7",Capacitor_SMD:CP_Elec_4x5.4,C3348
1N914BWS,"D1,D2",Diode_SMD:D_SOD-323F,C258181
CD4013BM96,IC1,Package_SO:SOIC-14_3.9x8.7mm_P1.27mm,C13527
MMBT3904,"Q1,Q2,Q3",Package_TO_SOT_SMD:SOT-23,C20526
2.2M,R1,Resistor_SMD:R_0603_1608Metric,C22938
330R,R103,Resistor_SMD:R_0603_1608Metric,C23138
150K,R2,Resistor_SMD:R_0603_1608Metric,C22807
1M,"R3,R7,R12,R20",Resistor_SMD:R_0603_1608Metric,C22935
470K,R4,Resistor_SMD:R_0603_1608Metric,C23178
1K,R5,Resistor_SMD:R_0603_1608Metric,C21190
56K,"R6,R9,R13,R14,R15,R16,R17,R18,R19,R101,R102",Resistor_SMD:R_0603_1608Metric,C23206
10K,"R8,R10,R11",Resistor_SMD:R_0603_1608Metric,C25804
RC4558DRG4,U1,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm,C7457

## KiCad design ChipLoop/ChipLoop.kicad_pcb

Parts:
C1, C5: 0.1uF; C_Flat_L7.2_H6.5
C2: 100uF; CP_Radial_D6.3mm_P2.50mm
C3: 1uF; C_Flat_L7.2_H10
C4: 0.33uF; C_Flat_L7.2_H6.5
D1, D2, D4, D5: LED; LED_D5.0mm
D3: LED; PinSocket_1x02_P2.54mm_Vertical
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
J2: Conn_02x25_Counter_Clockwise; N64-Connector-Wide
Q1: 2N3904; TO-92_Inline
R1, R3, R8, R10, R13: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R6, R7: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R9, R11, R12: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 82K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 500KL Volume; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV2: 100K; Potentiometer_Bourns_3386F_Vertical
SW1: SW_A; SW_PUSH_6mm
SW2: SW_B; SW_PUSH_6mm
U1: ATtiny84A-PU; DIP-14_W7.62mm
U2: ISD1820P; DIP-14_W7.62mm
U3: L78L05_TO92; TO-92_Inline

Connections:
+5V: C5.2, R9.1, U1.1 (VCC), U2.11 (VCC), U3.1 (VO)
+9V: C4.2, J2.5, J2.21, J2.30, J2.46, U3.3 (VI)
/FT: U1.9 (PA4), U2.12 (FT)
/Input: C3.1, J2.3, J2.23, J2.28, J2.48, R1.2
/LEDPower: D4.2 (A), D5.2 (A), J2.6, J2.20, J2.31, J2.45
/LED_A: R4.1, U1.8 (PA5)
/LED_B: R5.1, U1.5 (PB2)
/Loop: R6.2, U1.7 (PA6)
/Output: C3.2, J2.4, J2.22, J2.29, J2.47, RV1.2
/PLAYE: R10.2, U1.11 (PA2)
/PLAYL: R13.2, U1.10 (PA3)
/REC: R8.2, U1.12 (PA1)
/SW_A: SW1.1, U1.2 (XTAL1/PB0)
/SW_B: SW2.1, U1.3 (XTAL2/PB1)
GND: C4.1, C5.1, D1.1 (K), D2.1 (K), H1.1, H2.1, J2.1, J2.2, J2.24, J2.25, J2.26, J2.27, J2.49, J2.50, R2.1, R11.1, R12.2, RV1.3, RV2.1, SW1.2, SW2.2, U1.14 (GND), U2.8 (VSSA), U3.2 (GND)
unnamed: C1.1, R3.1
unnamed: C1.2, U2.4 (MIC)
unnamed: C2.1, U2.9 (SP+)
unnamed: C2.2, R7.2
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: D3.1 (K), Q1.3 (C), U2.13 (RECLED)
unnamed: D3.2 (A), R9.2
unnamed: D4.1 (K), R11.2
unnamed: D5.1 (K), R12.1
unnamed: Q1.1 (E), R10.1, U2.2 (PLAYE)
unnamed: Q1.2 (B), R6.1
unnamed: R1.1, R2.2, R3.2
unnamed: R7.1, RV1.1
unnamed: R8.1, U2.1 (REC)
unnamed: R13.1, U2.3 (PLAYL)
unnamed: R14.1, RV2.2, RV2.3
unnamed: R14.2, U2.10 (ROSC)

Board: 2 copper layers, 100.0 x 60.0 mm, 35 parts (0 on the bottom side), 33 nets.

## Commit log (part)

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2020-09-30 Added empty kicad project
2020-10-05 Moved files around
2020-10-05 Exported to Gerber
2020-10-05 Expanded ground plane on back
2020-10-10 Building basic fuzz circuit
2020-10-10 minor changes
2020-10-19 updated values
2020-10-25 Finished schematic. Still need to assign all footprints
2020-10-26 Added switches and led. Regenerated netlist
2020-10-26 Moved around items in pcb layout
2020-10-26 Added traces. Still need to finalize board
2020-10-27 Finalized board and plotted gerber files
2020-10-27 Moved text a little
2020-10-27 renamed zip file
2020-10-27 Added board with holes for THT 3PDT stomp switch
2020-10-27 Added zip with all gerber files
2020-10-28 Moved around components some more. Still needs to fix positions and add traces
2020-10-28 Update fp-info-cache
2020-10-29 Placed all traces and vias. Still need to finalize board
2020-10-29 Fixed library issue
2020-10-29 Added gerber files
2020-11-01 reorganization
2020-11-01 Finalized SMT CSV's. Placed order for PCBs based on this version
2020-11-03 Added audio jack library to make pin assignment easier
2020-11-03 Finalized component locations on pcb. Need to export BOM and pos files
2020-11-03 Added name and version number to silkscreen layer
2020-11-08 Setting up new project
2020-11-08 Finished schematic
2020-11-08 Finalized Board
2020-11-08 Added all traces to board. Need to add edge cuts
2020-11-08 Added edge cuts
2020-11-08 Fixed copper zones
2020-11-08 Rotated part for smt assembly
2020-11-10 Finalized sketch. Need to assign footprints
2020-11-10 Assigned some footprints
2020-11-10 Added DPDT switch footprint
2020-11-10 arranged some of the components on the pcb
2020-11-11 Moved around more parts on pcb. Need to extend top of pcb edge cuts
2020-11-11 Finalizing board. Still need to double check a few things before technically done.
2020-11-11 moved components away from edge. Turns out I selected the wrong footprints for some capacitors so that'll probably take some time to fix.
2020-11-12 Added grounding vias
2020-11-19 Added n64 logo and regenerated gerber files
2020-11-20 Added gerbers, BOM, and pos files
2020-12-11 Minor changes to footprints
2020-12-12 Switched from SMT to THT since component count is low. Boards finalized and order completed based on this version.
2020-12-17 Added fuzz schematic for console pedal. Just finished adding footprints
2020-12-17 Changed footprints
2021-01-02 Finalized fuzz board
2021-01-05 Added first part of echo circuit
2021-01-05 Finished adding symbols. Now assigning footprints to symbols
2021-01-05 Finished assigning footprints and generated netlist
2021-01-06 Finished placing traces
2021-01-08 Flipped potentiometers around
2021-01-08 Created Gerbers for both project before ordering
2021-01-08 Fixed typo on silkscreen
2021-01-08 JLCPCB doesn't accept Gerber X2 so I had to deselect an option when plotting. Hopefully this works :/
2021-02-06 Made polarized capacitors axial so lid could fit. Replotted gerber files
2021-02-06 Moved around components so they weren't so close together. Hopefully now I can use my film capacitors with this design
2021-02-06 Added jlcpcb order number location
2021-02-06 Moving polarity protection diode to mainboard so each cartridge doesn't need to have its own
2021-02-06 Removed reverse polarity protection diode since mainboard has it now
2021-02-06 Fixed missing grounding plane
2021-02-08 minor change
2021-02-08 Finalized schematic. Needs to assign footprints
2021-02-08 Assigned footprints. Need to add another resistor since the only ptv09 potentiometers I could find only went up to 500k
2021-02-09 Added trimpots since I couldn't get the main potentiometers to the right resistance on their own.
2021-02-10 Created my own footprint for one of those square capacitors to lay flat since the axial ones are a little too much in diameter
2021-02-10 Added minor missing things to silkscreen layer
2021-02-10 Exported gerber files and zipped for easy upload. Tremolo board ready for ordering
2021-02-12 Finalized schematic and assigned all footprints.
2021-02-12 Finished placement of components
2021-02-12 Fixed minor issues with silkscreen
2021-02-13 Finished schematic and assigned all footprints.
2021-02-13 Finalized board and traces. Gerbers have been exported and file is ready for ordering.
2021-02-15 Added some images
2021-03-27 Added basic board to make soldering together my 3D printed guitar body easier.
2021-03-27 Minor fixes
2021-03-31 Finalized schematic. Need to finish add on boards before making pcb
2021-03-31 Added early version of add on board and reverse polarity protection to mainboard
2021-04-03 Added initial arduino sketch
2021-04-03 Testing buttons and potentiometers
2021-04-10 Merging pedals into one board
2021-04-10 Started tracing everything out
2021-04-11 Finalized GuitarBoard. Plotted and zipped Gerber files
2021-04-11 Removed unneeded folders
2021-04-13 Switched which pedal came first. Added JLC order number location
2021-04-14 Finished schematic. Need to assign footprints
2021-04-14 Assigned all footprints. Now need to lay pcb out
2021-04-14 Starting new board and fixed minor silkscreen error in GuitarBoard
2021-04-15 Making an attempt at a label using original Doom artwork
2021-04-15 Updated version with better print settings
2021-04-16 Trying to fix print scaling
2021-04-16 Finally got the dimensions right
2021-04-16 Made panel better scaled
2021-04-20 Finalized board and exported gerbers
2021-04-21 Added power switch pins and replotted gerber files
2021-04-21 Flipped potentiometer to make more sense. Replotted Gerber files
2021-04-21 Fixed silkscreen
2021-04-21 Finalized slim portable amp and plotted Gerber files
2021-04-21 Added zip file for ordering
2021-04-21 Realized I need higher voltage tolerant capacitors. Still need to pick better ones.
2021-04-22 Fixed footprints and replotted Gerber files
2021-04-22 Changed text location for knobs
2021-04-22 Fixed color issues
2021-04-23 Added new graphics for labels
2021-04-23 Added more graphics
2021-04-24 Forgot to save
2021-04-24 Finalized ConsoleSocket pcb
2021-04-28 Added silhouette studio file for cutting labels
2021-05-04 Added extra to edges so cut outs wouldn't have white outline
2021-05-05 Added old graphics
2021-05-13 Added new pcb project
2021-05-13 Finalized schematic
2021-05-14 Finalized and plotted new board
2021-05-15 Removed unneeded files
2021-05-15 Finalized schematic of new amp circuit
2021-05-15 Starting working on board
2021-05-16 Finalized board and plotted gerbers
2021-05-26 Added new blank project
2021-05-26 Finalized board with two cartridge slots
2021-05-27 Finalized schematic. Still need to assign footprints
2021-05-27 Still working on plotting traces
2021-05-28 Finished schematic for new delay pedal. Need to assign footprints still
2021-05-28 Finished assigning footprints
2021-05-29 Still working on routing traces
2021-05-29 Finalized board and plotted gerbers. Had to use a 4 layer board for the first time
2021-05-29 Finalized schematic of new Boss DS-1 clone
2021-05-30 Fixed unconnected ground planes and replotted gerbers
2021-05-30 Fixed minor issue
2021-06-14 Changed footprint naming to add length
2021-06-15 Added new project to reverse engineer PedalPCB Terrarium board
2021-06-15 Reverse engineering is a lot harder than it looks
2021-06-16 Finalized schematic and assigned footprints
2021-06-19 Still placing components
2021-06-20 Finalized board traces. Now working on silkscreen
2021-06-20 Finalized pcb and plotted gerbers
2021-06-22 Made new empty project
2021-06-25 Made minor improvements. Might need to make a couple more before updating pcb
2021-06-27 Made label more readable
2021-06-28 Changed label color
2021-07-02 Built shake tremolo inside guitar board. Added separate schematic sheets since I ran out of space
2021-07-07 started to build schematic
2021-07-08 Added more to schematic
2021-07-09 Assigned all footprints and generated netlist
2021-07-09 Started to move around components
2021-07-19 Finished assigned LCSC numbers and new footprints for SMT assembly. Working on PCB layout rn
2021-07-19 Moved around some footprints
2021-07-19 Finalized board. Need to figure out how to export assembly instructions again.
2021-07-19 Finalized assembly files and made sure everything looked ok in the jlcpcb website
2021-07-20 Moved around some components
2021-07-21 Finalized phaser board and made a quick board to test jfets for phaser circuit
2021-07-21 Added jlc order number
2021-07-21 Added zip file
2021-07-27 Finished schematic. Trying to figure out how to fit all these components on this board
2021-07-27 Figured out how to fit components on board. Now need to add traces
2021-07-27 Finalized and plotted board
2021-08-02 Started working on a proto board type cartridge
2021-08-19 Working on SMT version of phaser pedal
2021-08-19 Finalized board and created assembly files
2021-08-19 Added zip
2021-08-19 Fixed rotation issues
2021-08-19 Starting new project for side by side console pedals
2021-08-28 Created new project for surface mount tremolo. JLCPCB assembly is having supply shortages so I might have to wait
2021-08-29 Finalized auto wah circuit
2021-08-29 Added switched connection for 9V
2021-09-14 Starting work on arduino Uno based console pedal
2021-09-17 Working on new pedal
2021-09-17 Finalized and exported Uno board
2021-09-18 Fixed footprints
2021-09-21 Added delay label and rearranged for printing
2021-09-22 created test page since printing was being weird
2021-09-26 Fixed footprints and replotted
2021-09-26 Finalized and plotted new version
2021-09-27 Working on Uno pedal code
2021-09-28 Added code to test LEDs
2021-09-28 LED effect selector works now. Just have to make the effect settings better
2021-10-05 Working on new design
2021-10-05 Finished schematic. Need to assign last footprints
2021-10-05 Placing components
2021-10-05 Component placements finalized
2021-10-08 Added new cartridge label
2021-10-21 Added new label
2021-10-21 Put new labels into pdf for printing
2021-10-22 Added new project and made my first KiCAD symbol
2021-10-29 Finalized project
2021-10-31 Started on new board for random attiny85 projects
2021-11-01 Forgot to add zip
2021-11-01 Started new project
2021-11-02 Finished schematic. Placing components now
2021-11-05 Added part types to schematic
2021-11-06 Added new project to fit more stuff in 3D printed guitar
2021-11-13 Added 3 blinks for led to test timer and button debounce
2021-11-14 Added button logic
2021-11-14 Changed delay times
2021-11-24 Added new project to drive oled tuner inside 3D printed guitar
2021-11-25 Trying to get everything to fit in the 3D printed pocket I've made
2021-11-25 Trying to get board dimensions right
2021-11-27 Moved some stuff around for readability
2021-12-01 Finalized speaker board
2021-12-01 Working on new version of guitar board
2021-12-01 Finalized changes to chip loop input and output
2021-12-06 Started on new pcb
2021-12-18 Cache update
2021-12-21 Added new empty project to put arduino code
2021-12-23 Finalized and exported fm receiver board
2021-12-28 Fixed minor issues and reduced board size
2021-12-29 Added new empty project
2021-12-31 Created new symbol, library, and code for transmitter cartridge
2022-02-13 Made changes to code for new board
2022-02-17 First attempt at adapting code. Doesn't work so far
2022-02-18 Fixed FM transmitter and receiver code
2022-03-27 Added new project
2022-03-27 Finished component placement
2022-03-27 Half of tracks laid out
2022-03-28 Finalized traces. Need to export assembly files
2022-03-28 Added more info to silkscreen
2022-03-28 Fixed incorrect footprint and exported everything again
2022-03-28 PCBs ordered
2022-04-04 Switched input and output jack locations
2022-04-05 Made pin holes wider for easier hand soldering
2022-04-09 Added new SMT project
2022-04-09 Assigned some new footprints
2022-04-09 Finalized board. Need to export and adjust for assembly
2022-04-10 Created new SMT project
2022-04-10 Finalized SMT project and fixed minor issues
2022-04-10 Fixed rotation
2022-04-11 Finalized new SMT project
2022-07-08 Added image files
