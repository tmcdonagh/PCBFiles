# Repository tmcdonagh/PCBFiles

## KiCad design ConsolePedalDelaySMT/ConsolePedalDelaySMT.kicad_pcb

Parts:
C1, C11: 22nF; C_Flat_L7.2_H6.5
C2: 47pF; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C3: 100pF; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C4, C5, C13, C14: 1uF; CP_Radial_D5.0mm_P2.00mm_L11.0mm
C6: 4.7nF; C_Flat_L7.2_H6.5
C7, C8: 2.2nF; C_Flat_L7.2_H6.5
C9, C10, C18, C19: 100nF; C_Flat_L7.2_H6.5
C12: 10nF; C_Flat_L7.2_H6.5
C15: 47nF; C_Flat_L7.2_H6.5
C16: 15nF; C_Flat_L7.2_H6.5
C17, C21, C22: 47uF; CP_Radial_D6.3mm_P2.50mm_L7.0mm
C20: 100uF; CP_Radial_D6.3mm_P2.00mm_L11.0mm
D1: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D3: LED; LED_D5.0mm
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: Conn_02x25_Counter_Clockwise; N64-Connector
R1: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 180K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 360K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 12K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R13: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8, R9, R12, R16, R19, R20: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R15: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R21: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: Delay 50KB; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV2: Level 50KB; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV3: Repeat 50KB; Potentiometer_Bourns_PTV09A-1_Single_Vertical
U1: TL072; DIP-8_W7.62mm_Socket
U2: PT2399; DIP-16_W7.62mm_Socket
U3: L78L05_TO92; TO-92_Inline

Connections:
+9V: J1.5, J1.21, J1.30, J1.46, R18.2
/5V: C22.1, U2.1 (VCC), U3.1
/Input: C1.2, J1.3, J1.23, J1.28, J1.48, R1.2
/LEDPower: D2.2 (A), D3.2 (A), J1.6, J1.20, J1.31, J1.45
/Output: J1.4, J1.22, J1.29, J1.47, R6.2
/VREF: C21.1, R19.2, R20.1, U1.3 (+), U1.5 (+)
/pin2: C17.1, U2.2 (REF)
/pin4: RV1.3, U2.4 (DGND)
/pin6: R17.1, U2.6 (VCO)
/pin7: C18.1, U2.7 (CC1)
/pin8: C19.1, U2.8 (CC0)
/pin9: C10.2, U2.9 (OP1-OUT)
/pin10: C10.1, U2.10 (OP1-IN)
/pin11: C9.2, U2.11 (OP2-IN)
/pin12: C9.1, R16.2, U2.12 (OP2-OUT)
/pin13: C8.2, R12.1, U2.13 (LPF2-IN)
/pin14: C8.1, R11.1, R13.1, U2.14 (LPF2-OUT)
/pin15: C7.2, R9.2, U2.15 (LPF1-OUT)
/pin16: C7.1, R8.1, U2.16 (LPF1-IN)
GND: C6.2, C12.1, C15.1, C16.1, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, H1.1, H2.1, J1.1, J1.2, J1.24, J1.25, J1.26, J1.27, J1.49, J1.50, R1.1, R20.2, R21.1, RV2.3, RV3.3, U1.4 (V-), U2.3 (AGND), U3.2; also elsewhere on the board
unnamed: C1.1, R2.1
unnamed: C2.1, R2.2, R3.2, U1.2 (-)
unnamed: C2.2, C5.1, R3.1, R4.1, U1.1
unnamed: C3.1, R4.2, R5.1, R15.1, U1.6 (-)
unnamed: C3.2, C4.1, R5.2, U1.7
unnamed: C4.2, R6.1
unnamed: C5.2, R7.2
unnamed: C6.1, R7.1, R8.2, R9.1, R10.1
unnamed: C11.1, RV3.1
unnamed: C11.2, R10.2
unnamed: C12.2, C13.1, R13.2
unnamed: C13.2, R14.1, RV2.1
unnamed: C14.1, R15.2
unnamed: C14.2, RV2.2
unnamed: C15.2, R14.2, RV3.2
unnamed: C16.2, R11.2, R12.2, R16.1
unnamed: C20.1, R18.1, R19.1, U1.8 (V+), U3.3
unnamed: R17.2, RV1.1, RV1.2

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
Board: 2 copper layers, 100.0 x 60.0 mm, 57 parts (0 on the bottom side), 40 nets.

Other parts of the board:
R22, R24: 100K; R_0603_1608Metric
R23: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Their connections:
GND: R22.1, R23.1, R24.1; also elsewhere on the board

File ConsolePedalDelaySMT/assembly/ConsolePedalDelaySMT-BOM.csv:

Comment,Designator,Footprint,LCSC
22nF,"C1,C11",Capacitor_SMD:C_0805_2012Metric, C1729
10nF,C12,Capacitor_SMD:C_0805_2012Metric,C1710
47nF,C15,Capacitor_SMD:C_0805_2012Metric,C53134
15nF,C16,Capacitor_SMD:C_0805_2012Metric,C52412
47uF,"C17,C21,C22",Capacitor_SMD:CP_Elec_6.3x5.7,C134832
47pF,C2,Capacitor_SMD:C_0805_2012Metric,C14857
100uF,C20,Capacitor_SMD:CP_Elec_6.3x5.3,C134723
100pF,C3,Capacitor_SMD:C_0805_2012Metric,C1790
1uF,"C4,C5,C13,C14",Capacitor_SMD:CP_Elec_6.3x5.3,C134723
4.7nF,C6,Capacitor_SMD:C_0805_2012Metric,C1744
2.2nF,"C7,C8",Capacitor_SMD:C_0805_2012Metric,C28260
100nF,"C9,C10,C18,C19",Capacitor_SMD:C_0805_2012Metric,C49678
1N5817,D1,Diode_SMD:D_SOD-123,C727113
1M,R1,Resistor_SMD:R_0603_1608Metric,C22935
5.1K,R10,Resistor_SMD:R_0603_1608Metric,C23186
2K,R14,Resistor_SMD:R_0603_1608Metric,C22975
20K,"R11,R15",Resistor_SMD:R_0603_1608Metric,C4184
2.2K,R17,Resistor_SMD:R_0603_1608Metric,C4190
33,R18,Resistor_SMD:R_0603_1608Metric,C23140
180K,R2,Resistor_SMD:R_0603_1608Metric,C22827
360K,R3,Resistor_SMD:R_0603_1608Metric,C23146
22K,R4,Resistor_SMD:R_0603_1608Metric,C31850
12K,R5,Resistor_SMD:R_0603_1608Metric,C22790
1K,"R6,R13",Resistor_SMD:R_0603_1608Metric,C21190
10K,"R7,R8,R9,R12,R16,R19,R20",Resistor_SMD:R_0603_1608Metric,C25804
TL072,U1,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm,C6961

## KiCad design ConsolePedalDistortionSMT/ConsolePedalDistortionSMT.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0603_1608Metric; LCSC C14663
D1, D2: LED; LED_D5.0mm
D3, D4: 1N4148W; D_SOD-123; LCSC C81598
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: Conn_02x25_Counter_Clockwise; N64-Connector-Wide
Q1: MMBT3904; SOT-23; LCSC C20526
R1: 2M; R_0603_1608Metric; LCSC C22976
R2: 4.7K; R_0603_1608Metric; LCSC C23162
R3, R6: 100K; R_0603_1608Metric; LCSC C25803
R4, R5: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 250K Distortion; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV2: 250K Volume; Potentiometer_Bourns_PTV09A-1_Single_Vertical

Connections:
+9V: J1.5, J1.21, J1.30, J1.46, R2.1
/Input: J1.3, J1.23, J1.28, J1.48, RV1.2, RV1.3
/LEDPower: D1.2 (A), D2.2 (A), J1.6, J1.20, J1.31, J1.45
/Output: J1.4, J1.22, J1.29, J1.47, RV2.2
GND: D3.2 (A), D4.1 (K), H1.1, H2.1, J1.1, J1.2, J1.24, J1.25, J1.26, J1.27, J1.49, J1.50, Q1.2 (E), R3.1, R4.1, R5.1, R6.1, RV2.3
unnamed: C1.1, Q1.1 (B), R1.1
unnamed: C1.2, RV1.1
unnamed: C2.1, D3.1 (K), D4.2 (A), RV2.1
unnamed: C2.2, Q1.3 (C), R1.2, R2.2
unnamed: D1.1 (K), R3.2, R4.2
unnamed: D2.1 (K), R5.2, R6.2

Board: 2 copper layers, 100.0 x 60.0 mm, 18 parts (0 on the bottom side), 11 nets.

File ConsolePedalDistortionSMT/assembly/ConsolePedalDistortionSMT-BOM.csv:

Comment,Designator,Footprint,LCSC
0.1uF,"C1,C2",Capacitor_SMD:C_0603_1608Metric,C14663
1N4148W,"D3,D4",Diode_SMD:D_SOD-123,C81598
MMBT3904,Q1,Package_TO_SOT_SMD:SOT-23,C20526
2M,R1,Resistor_SMD:R_0603_1608Metric,C22976
4.7K,R2,Resistor_SMD:R_0603_1608Metric,C23162
100K,"R3,R6",Resistor_SMD:R_0603_1608Metric,C25803

## KiCad design ConsolePedalFuzzSMT/ConsolePedalFuzzSMT.kicad_pcb

Parts:
C1: 2.2uF; CP_Elec_6.3x5.4; LCSC C335981
C2: 0.01uF; C_0603_1608Metric; LCSC C57112
C3: 22uF; CP_Elec_6.3x5.4; LCSC C72505
D1, D2: LED; LED_D5.0mm
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: Conn_02x25_Counter_Clockwise; N64-Connector-Wide
Q1, Q2: MMBT3904; SOT-23; LCSC C20526
R1: 33K; R_0603_1608Metric; LCSC C4216
R2, R8: 330; R_0603_1608Metric; LCSC C23138
R3, R5: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 100K; R_0603_1608Metric; LCSC C25803
R6, R7: 120K; R_0603_1608Metric; LCSC C25808
RV1: 1K; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV2: 500K; Potentiometer_Bourns_PTV09A-1_Single_Vertical
RV3: THT; Potentiometer_Bourns_3386F_Vertical

Connections:
+9V: J1.5, J1.21, J1.30, J1.46, R1.2, R2.2
/Input: C1.2, J1.3, J1.23, J1.28, J1.48
/LEDPower: D1.2 (A), D2.2 (A), J1.6, J1.20, J1.31, J1.45
/Output: J1.4, J1.22, J1.29, J1.47, RV2.2
GND: C3.2, H1.1, H2.1, J1.1, J1.2, J1.24, J1.25, J1.26, J1.27, J1.49, J1.50, Q1.2 (E), R3.1, R5.2, R6.2, R7.1, RV1.3, RV2.3
unnamed: C1.1, Q1.1 (B), R4.1
unnamed: C2.1, RV2.1
unnamed: C2.2, R2.1, R8.2, RV3.1
unnamed: C3.1, RV1.2
unnamed: D1.1 (K), R5.1, R6.1
unnamed: D2.1 (K), R3.2, R7.2
unnamed: Q1.3 (C), Q2.1 (B), R1.1
unnamed: Q2.2 (E), R4.2, RV1.1
unnamed: Q2.3 (C), R8.1, RV3.2

Board: 2 copper layers, 100.0 x 60.0 mm, 21 parts (0 on the bottom side), 14 nets.

File ConsolePedalFuzzSMT/assembly/ConsolePedalFuzzSMT-BOM.csv:

Comment,Designator,Footprint,LCSC
2.2uF,C1,Capacitor_SMD:CP_Elec_6.3x5.4,C335981
0.01uF,C2,Capacitor_SMD:C_0603_1608Metric,C57112
22uF,C3,Capacitor_SMD:CP_Elec_6.3x5.4,C72505
MMBT3904,"Q1,Q2",Package_TO_SOT_SMD:SOT-23,C20526
33K,R1,Resistor_SMD:R_0603_1608Metric,C4216
330,"R2,R8",Resistor_SMD:R_0603_1608Metric,C23138
100K,R4,Resistor_SMD:R_0603_1608Metric,C25803
120K,"R6,R7",Resistor_SMD:R_0603_1608Metric,C25808

## KiCad design ConsolePedal8BitarSMT/ConsolePedal8BitarSMT.kicad_pcb

Board: 2 copper layers, 100.0 x 60.0 mm, 27 parts (0 on the bottom side), 19 nets.

Parts:
C1, C3: 0.1uF; C_Flat_L7.2_H6.5
C2: 2200pF; C_Flat_L7.2_H6.5
C4: 4700pF; C_Flat_L7.2_H6.5
C5, C8: 10uF; CP_Axial_L10.0mm_D6.0mm_P15.00mm_Horizontal
C6: 100pF; C_Flat_L7.2_H6.5
C7: 1000pF; C_Flat_L7.2_H6.5
D1, D2: LED; LED_D5.0mm
D3: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
IC1: CD4069UBE; DIP794W53P254L1930H508Q14N
J1: Conn_02x25_Counter_Clockwise; N64-Connector-Wide
Q1: 2N3904; TO-92_Inline
R1, R2, R4, R6: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R10: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8, R9: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: A10K; Potentiometer_Bourns_PTV09A-1_Single_Vertical

Connections:
+9V: C5.1, D3.1, IC1.14, J1.5, J1.21, J1.30, J1.46
/Input: C1.2, J1.3, J1.23, J1.28, J1.48, R1.1
/LEDPower: D1.2, D2.2, J1.6, J1.20, J1.31, J1.45
/Output: J1.4, J1.22, J1.29, J1.47, RV1.2
/pin1: IC1.1, R5.1, R6.2
/pin3: C3.1, C4.2, IC1.3, R4.2
/pin4: C4.1, IC1.4, R4.1, R5.2
/pin5: C1.1, C2.2, IC1.5, R2.2
/pin6: C2.1, C3.2, IC1.6, R2.1
/pin9: IC1.9, Q1.3, R9.2
/pin10: C8.1, IC1.10, R9.1
/pin11: IC1.8, IC1.11, R10.2
/pin12: C6.2, IC1.12, R6.1, R7.1
/pin13: IC1.2, IC1.13
GND: C5.2, C7.1, D3.2, H1.1, H2.1, IC1.7, J1.1, J1.2, J1.24, J1.25, J1.26, J1.27, J1.49, J1.50, R1.2, R3.1, R8.2, RV1.3
unnamed: C6.1, Q1.2, R7.2, R8.1
unnamed: C7.2, Q1.1, R10.1
unnamed: C8.2, RV1.1
unnamed: D1.1, D2.1, R3.2

File ConsolePedal8BitarSMT/assembly/ConsolePedal8BitarSMT-BOM.csv:

Comment,Designator,Footprint,LCSC
0.1uF,"C1,C3",Capacitor_SMD:C_0603_1608Metric,C14663
2200pF,C2,Capacitor_SMD:C_0603_1608Metric,C1604
4700pF,C4,Capacitor_SMD:C_0603_1608Metric,C53987
100pF,C6,Capacitor_SMD:C_0603_1608Metric,C14858
1000pF,C7,Capacitor_SMD:C_0603_1608Metric,C1588
10uF,"C5,C8",Capacitor_SMD:CP_Elec_5x5.4,C72487
CD4069UBM,IC2,Package_SO:SOIC-14_3.9x8.7mm_P1.27mm,C93672
MMBT3904,Q1,Package_TO_SOT_SMD:SOT-23,
1M,"R1,R2,R4,R6",Resistor_SMD:R_0603_1608Metric,C22935
100K,R10,Resistor_SMD:R_0603_1608Metric,C25803
22K,"R12,R13",Resistor_SMD:R_0603_1608Metric,C31850
47K,R5,Resistor_SMD:R_0603_1608Metric,C25819
10K,"R7,R8,R9",Resistor_SMD:R_0603_1608Metric,C25804

## KiCad design ConsolePedalSide/ConsolePedalSide.kicad_pcb

Parts:
BT1: 9V; PinSocket_1x02_P2.54mm_Vertical
D1, D3: LED; LED_D5.0mm
D2: D; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: Mount; MountingHole_2.5mm_Pad
J1: AudioJack3; Pins_1x03_Wide
J2: AudioJack2; Pins_1x02_Wide
J3: SlotA; PinSocket_1x05_P2.54mm_Vertical
J4: SlotB; PinSocket_1x05_P2.54mm_Vertical
R1, R2: LED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
S1: SlotASwitch; STOMP_SWITCH_3PDT
S2: SlotBSwitch; STOMP_SWITCH_3PDT

Connections:
+9V: D2.1 (K), J3.2, J4.2, S1.P$8, S2.P$8
/SlotAInput: J3.4, S1.P$3 (S)
/SlotALED: D1.2 (A), J3.1, S1.P$9 (S)
/SlotAOutput: J3.3, S1.P$6 (S)
/SlotBInput: J4.4, S2.P$3 (S)
/SlotBLED: D3.2 (A), J4.1, S2.P$9 (S)
/SlotBOutput: J4.3, S2.P$6 (S)
GND: H1.1, H2.1, H3.1, H4.1, J1.1, J2.2, J3.5, J4.5, R1.2, R2.2
unnamed: BT1.1 (+), D2.2 (A)
unnamed: BT1.2 (-), J1.2
unnamed: D1.1 (K), R1.1
unnamed: D3.1 (K), R2.1
unnamed: J1.3, S1.P$2
unnamed: J2.1, S2.P$5
unnamed: S1.P$1 (O), S1.P$4 (O)
unnamed: S1.P$5, S2.P$2
unnamed: S2.P$1 (O), S2.P$4 (O)

Board: 2 copper layers, 93.0 x 31.6 mm, 16 parts (0 on the bottom side), 17 nets.

## KiCad design ConsoleSocket/ConsoleSocket.kicad_pcb

Parts:
H1, H2: Mount; MountingHole_2.5mm_Pad
J1: Conn; Pins_1x06_Wide
J3: Conn_02x25_Odd_Even; n64Socket

Connections:
+9V: J1.5, J3.9, J3.41
/Input: J1.2, J3.5, J3.6, J3.45, J3.46
/LEDPower: J1.4, J3.11, J3.12, J3.39, J3.40
/Output: J1.3, J3.7, J3.8, J3.43, J3.44
/SW: J1.6, J3.10, J3.42
GND: H1.1, H2.1, J1.1, J3.1, J3.2, J3.3, J3.4, J3.47, J3.48, J3.49, J3.50

Board: 2 copper layers, 95.0 x 15.2 mm, 4 parts (0 on the bottom side), 6 nets.

## KiCad design ConsolePedalBlueSoxSMT/ConsolePedalBlueSoxSMT.kicad_pcb

Parts:
C1, C9: 10nF; C_0603_1608Metric; LCSC C57112
C2: 1nF; C_0603_1608Metric; LCSC C1588
C3, C10: 150pF; C_0603_1608Metric; LCSC C1594
C4, C101: 10uF; CP_Elec_4x5.4; LCSC C72485
C5, C8: 47nF; C_0603_1608Metric; LCSC C1622
C6, C7: 1uF; CP_Elec_4x5.4; LCSC C3348
C100, C102: 100uF; CP_Elec_6.3x5.3; LCSC C176674
C103: 100nF; C_0603_1608Metric; LCSC C14663
D1, D2: 1N914; D_SOD-323F; LCSC C258181
D3, D4: LED; LED_D5.0mm
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
IC1: CD4013BE; SOIC-14_3.9x8.7mm_P1.27mm; Mouser Part Number 595-CD4013BE
J1: Conn_02x25_Counter_Clockwise; N64-Connector-Wide
Q1, Q2, Q3: 2N3904; SOT-23; LCSC C20526
R1: 2.2M; R_0603_1608Metric; LCSC C22938
R2: 150K; R_0603_1608Metric; LCSC C22807
R3, R7, R12, R20: 1M; R_0603_1608Metric; LCSC C22935
R4: 470K; R_0603_1608Metric; LCSC C23178
R5: 1K; R_0603_1608Metric; LCSC C21190
R6, R9, R13, R14, R15, R16, R17, R18, R19, R101, R102: 56K; R_0603_1608Metric; LCSC C23206
R8, R10, R11: 10K; R_0603_1608Metric; LCSC C25804
R21, R22: RLED; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R103: 330R; R_0603_1608Metric; LCSC C23138
RV1, RV2: 50KA; Potentiometer_Bourns_PTV09A-1_Single_Vertical
U1: RC4558; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7457

Connections:
+9V: C100.1, J1.5, J1.21, J1.30, J1.46, R11.1, R101.2, R103.2, U1.8 (V+)
/CLK2: IC1.11 (CLOCK2), Q1.3 (C), R11.2, R12.1
/Input: J1.3, J1.23, J1.28, J1.48, R1.2, R2.2
/LEDPower: D3.2 (A), D4.2 (A), J1.6, J1.20, J1.31, J1.45
/Output: J1.4, J1.22, J1.29, J1.47, RV2.2
/Q1: IC1.1 (Q1), R20.1
/VREF: C2.1, C4.2, C101.1, R3.2, R6.2, R8.2, R101.1, R102.2
GND: C7.2, C9.2, C100.2, C101.2, C102.2, C103.1, D2.2 (A), H1.1, H2.1, IC1.4 (RESET1), IC1.6 (SET1), IC1.7 (VSS), IC1.8 (SET2), IC1.10 (RESET2), J1.1, J1.2, J1.24, J1.25, J1.26, J1.27, J1.49, J1.50, Q1.1 (E), Q2.1 (E), Q3.1 (E), R1.1, R10.2, R14.1, R21.1, R22.1, R102.1, RV1.2, RV2.3, U1.4 (V-)
unnamed: C1.1, C2.2, R3.1, U1.3 (+)
unnamed: C1.2, R2.1
unnamed: C4.1, R5.1
unnamed: C5.2, R6.1, U1.6 (-)
unnamed: C6.2, D1.2 (A), D2.1 (K)
unnamed: C7.1, D1.1 (K), R13.2, R14.2, R19.2
unnamed: C8.1, R16.2, R17.2
unnamed: C8.2, C9.1, RV2.1
unnamed: C3.1, C10.1, R4.2, R5.2, U1.2 (-)
unnamed: C3.2, C5.1, C6.1, C10.2, R4.1, U1.1
unnamed: D3.1 (K), R21.2
unnamed: D4.1 (K), R22.2
unnamed: IC1.2 (~Q1), IC1.5 (D1)
unnamed: IC1.9 (D2), IC1.12 (~Q2)
unnamed: IC1.3 (CLOCK1), IC1.13 (Q2)
unnamed: Q1.2 (B), R9.2, R10.1
unnamed: Q2.2 (B), R12.2
unnamed: Q2.3 (C), R13.1, R15.2
unnamed: Q3.2 (B), R20.2
unnamed: Q3.3 (C), R18.1, R19.1
unnamed: R7.1, R8.1, U1.5 (+)
unnamed: R7.2, R9.1, U1.7
unnamed: R15.1, R16.1, RV1.1
unnamed: R17.1, R18.2, RV1.3
VDD: C102.1, C103.2, IC1.14 (VDD), R103.1
